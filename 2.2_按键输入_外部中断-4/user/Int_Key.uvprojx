# Keil uVision project Int_Key.uvprojx, settings and files
target Int_Key (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Int_Key +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\hardware\exti;..\hardware\KEY;..\hardware\LED;..\system\delay;..\system\sys
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Hardware
    ../hardware/exti/: exti.c
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
  group System
    ../system/delay/: delay.c
    ../system/sys/: sys.c
  group User
    ./: Int_Key.c stm32f10x.s
