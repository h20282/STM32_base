# Keil uVision project GPIO_REG.uvproj, settings and files
target GPIO_REG (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO_REG +hex
  c flags: Optim=1
  c include: .\Sys;.\Hardware
  asm include: .\Sys;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/: led.c
  group Sys
    ./Sys/: STM32F10x.s delay.c sys.c
