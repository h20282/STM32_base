# Keil uVision project 8_SegLED.uvprojx, settings and files
target 8SegLED (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 8_SegLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HAEDWARE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HardWare
    ../HAEDWARE/: led.c
  group User
    ../USER/: main.c STM32F10x.s
software components: CMSIS:CORE 5.3.0
