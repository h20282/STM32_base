# Keil uVision project uCosII.uvproj, settings and files
target uCosII Test (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCos252 +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\UCOSII\CORE;..\UCOSII\PORT;..\APP;..\UCOSII\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: STM32F10x.s uCosMain.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group uC/OS-II CORE
    ../UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group uC/OS-II PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC/OS-II CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
